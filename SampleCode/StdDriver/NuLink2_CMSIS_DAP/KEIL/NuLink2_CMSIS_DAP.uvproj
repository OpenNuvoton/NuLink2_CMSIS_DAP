# Keil uVision project NuLink2_CMSIS_DAP.uvproj, settings and files
target NuLink2_CMSIS_DAP (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: NuLink2_CMSIS_DAP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c descriptors.c hid_transfer.c DAP_config.h IO_Config.h
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c retarget.c hsusbd.c gpio.c
  group DAP
    ../DAP/: DAP.c JTAG_DP.c SW_DP.c SWO.c
  group Voltage
    ../Voltage/: Voltage.h Voltage.lib
